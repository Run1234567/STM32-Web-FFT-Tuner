# Keil uVision project test.uvprojx, settings and files
target test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTC +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,ARM_MATH_CM4, __FPU_PRESENT=1
  c misc: --diag_suppress=1
  c include: ..\StartUp;..\Library_RUN;..\STM32F40X_Lib\inc;..\Library_Algorithm_RUN;..\Library_Device_RUN;..\Code
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../StartUp/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group App
    ../App/: main.c
  group STM32F4XX_Lib
    ../STM32F40X_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Library_RUN
    ../Library_RUN/: RUN_header_file.h RUN_GPIO.c RUN_GPIO.h RUN_Delay.c RUN_Delay.h RUN_UART.c RUN_UART.h RUN_ISR.c RUN_ISR.h RUN_Timer.c RUN_Timer.h RUN_PWM.c RUN_PWM.h RUN_Exti.c RUN_Exti.h RUN_ADC.c RUN_ADC.h RUN_DAC.c RUN_DAC.h RUN_SoftI2C.c RUN_SoftI2C.h
  group Code
    ../Code/: ADC_DMA.c ADC_DMA.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0
